# Keil uVision project project.uvprojx, settings and files
target lvgl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  AfterMake: .\after_build_common.bat $J #L @L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_MATH_CM4, RTK_HAL_I2C, RTL8762D, LV_LVGL_H_INCLUDE_SIMPLE, RTK_HAL_DRIVER, LV_USE_DEMO_BENCHMARK, SUPPORT_ALONE_UPPERSTACK_IMG, ENABLE_LVGL_GUI, RTK_HAL_DLPS, RTK_HAL_GPIO, LV_KCONFIG_IGNORE, RTK_HAL_RTC, RTK_HAL_LCD, RTK_HAL_FLASH, RTK_HAL_TOUCH = "1", LV_CONF_INCLUDE_SIMPLE, LV_USE_DEMO_WIDGETS, DEFINE_RTK_BT_TODO
  c misc: --gnu --preinclude mem_config.h  --preinclude app_define.h --bss_threshold=0  --diag_suppress=550  --diag_suppress=186
  c include: ..;..\src;..\src\root_image;..\..\..\..\inc;..\..\..\..\inc\app;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\inc\os;..\..\..\..\inc\os\osif;..\..\..\..\src\dfu;..\..\..\..\inc\os\FreeRTOS;..\..\..\..\inc\bluetooth;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc;..\..\..\..\inc\app;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\inc\os;..\..\..\..\inc\os\osif;..\..\..\..\src\dfu;..\..\..\..\inc\os\FreeRTOS;..\..\..\..\inc\bluetooth;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\inc\bluetooth\gap;..\src\lvgl_port;..\..\..\..\src\app\Wearable\audio\music_player;..\..\..\..\src\app\Wearable\communicate\rtk_bt;..\..\..\..\src\app\Wearable\device\lcd\8762D;..\..\..\..\src\app\Wearable\device\lcd\8762G;..\..\..\..\src\app\Wearable\device\lcd\8772F;..\..\..\..\src\app\Wearable\device\touch\8762D;..\..\..\..\src\app\Wearable\device\touch\8762G;..\..\..\..\src\app\Wearable\driver\io;..\..\..\..\src\app\Wearable\system\clock;..\..\..\..\src\app\lvgl;..\..\..\..\src\app\lvgl\src;..\..\..\..\src\app\lvgl\src\core;..\..\..\..\src\app\lvgl\src\display;..\..\..\..\src\app\lvgl\src\draw;..\..\..\..\src\app\lvgl\src\drivers;..\..\..\..\src\app\lvgl\src\font;..\..\..\..\src\app\lvgl\src\indev;..\..\..\..\src\app\lvgl\src\layouts;..\..\..\..\src\app\lvgl\src\misc;..\..\..\..\src\app\lvgl\src\osal;..\..\..\..\src\app\lvgl\src\stdlib;..\..\..\..\src\app\lvgl\src\themes;..\..\..\..\src\app\lvgl\src\tick;..\..\..\..\src\app\lvgl\src\draw\convert;..\..\..\..\src\app\lvgl\src\draw\dma2d;..\..\..\..\src\app\lvgl\src\draw\eve;..\..\..\..\src\app\lvgl\src\draw\nema_gfx;..\..\..\..\src\app\lvgl\src\draw\opengles;..\..\..\..\src\app\lvgl\src\draw\rtk;..\..\..\..\src\app\lvgl\src\draw\sdl;..\..\..\..\src\app\lvgl\src\draw\sw;..\..\..\..\src\app\lvgl\src\draw\vg_lite;..\..\..\..\src\app\lvgl\src\draw\convert\helium;..\..\..\..\src\app\lvgl\src\draw\convert\neon;..\..\..\..\src\app\lvgl\src\draw\espressif\ppa;..\..\..\..\src\app\lvgl\src\draw\nxp\g2d;..\..\..\..\src\app\lvgl\src\draw\nxp\pxp;..\..\..\..\src\app\lvgl\src\draw\ppe\rtl8773e;..\..\..\..\src\app\lvgl\src\draw\ppe\rtl8773g;..\..\..\..\src\app\lvgl\src\draw\ppe\rtl87x2g;..\..\..\..\src\app\lvgl\src\draw\renesas\dave2d;..\..\..\..\src\app\lvgl\src\draw\sw\arm2d;..\..\..\..\src\app\lvgl\src\draw\sw\blend;..\..\..\..\src\app\lvgl\src\draw\sw\blend\arm2d;..\..\..\..\src\app\lvgl\src\draw\sw\blend\helium;..\..\..\..\src\app\lvgl\src\draw\sw\blend\neon;..\..\..\..\src\app\lvgl\src\drivers\evdev;..\..\..\..\src\app\lvgl\src\drivers\libinput;..\..\..\..\src\app\lvgl\src\drivers\nuttx;..\..\..\..\src\app\lvgl\src\drivers\opengles;..\..\..\..\src\app\lvgl\src\drivers\qnx;..\..\..\..\src\app\lvgl\src\drivers\sdl;..\..\..\..\src\app\lvgl\src\drivers\uefi;..\..\..\..\src\app\lvgl\src\drivers\wayland;..\..\..\..\src\app\lvgl\src\drivers\windows;..\..\..\..\src\app\lvgl\src\drivers\x11;..\..\..\..\src\app\lvgl\src\drivers\display\drm;..\..\..\..\src\app\lvgl\src\drivers\display\fb;..\..\..\..\src\app\lvgl\src\drivers\display\ft81x;..\..\..\..\src\app\lvgl\src\drivers\display\ili9341;..\..\..\..\src\app\lvgl\src\drivers\display\lcd;..\..\..\..\src\app\lvgl\src\drivers\display\lovyan_gfx;..\..\..\..\src\app\lvgl\src\drivers\display\nv3007;..\..\..\..\src\app\lvgl\src\drivers\display\nxp_elcdif;..\..\..\..\src\app\lvgl\src\drivers\display\renesas_glcdc;..\..\..\..\src\app\lvgl\src\drivers\display\st7735;..\..\..\..\src\app\lvgl\src\drivers\display\st7789;..\..\..\..\src\app\lvgl\src\drivers\display\st7796;..\..\..\..\src\app\lvgl\src\drivers\display\st_ltdc;..\..\..\..\src\app\lvgl\src\drivers\display\tft_espi;..\..\..\..\src\app\lvgl\src\drivers\draw\eve;..\..\..\..\src\app\lvgl\src\drivers\opengles\assets;..\..\..\..\src\app\lvgl\src\drivers\opengles\opengl_shader;..\..\..\..\src\app\lvgl\src\drivers\opengles\glad\include\EGL;..\..\..\..\src\app\lvgl\src\drivers\opengles\glad\include\glad;..\..\..\..\src\app\lvgl\src\drivers\opengles\glad\include\KHR;..\..\..\..\src\app\lvgl\src\layouts\flex;..\..\..\..\src\app\lvgl\src\layouts\grid;..\..\..\..\src\app\lvgl\src\libs\avi;..\..\..\..\src\app\lvgl\src\libs\barcode;..\..\..\..\src\app\lvgl\src\libs\bin_decoder;..\..\..\..\src\app\lvgl\src\libs\bmp;..\..\..\..\src\app\lvgl\src\libs\expat;..\..\..\..\src\app\lvgl\src\libs\ffmpeg;..\..\..\..\src\app\lvgl\src\libs\freetype;..\..\..\..\src\app\lvgl\src\libs\fsdrv;..\..\..\..\src\app\lvgl\src\libs\FT800-FT813;..\..\..\..\src\app\lvgl\src\libs\gif;..\..\..\..\src\app\lvgl\src\libs\gstreamer;..\..\..\..\src\app\lvgl\src\libs\jpu;..\..\..\..\src\app\lvgl\src\libs\libjpeg_turbo;..\..\..\..\src\app\lvgl\src\libs\libpng;..\..\..\..\src\app\lvgl\src\libs\lodepng;..\..\..\..\src\app\lvgl\src\libs\lz4;..\..\..\..\src\app\lvgl\src\libs\qrcode;..\..\..\..\src\app\lvgl\src\libs\rle;..\..\..\..\src\app\lvgl\src\libs\rlottie;..\..\..\..\src\app\lvgl\src\libs\svg;..\..\..\..\src\app\lvgl\src\libs\thorvg;..\..\..\..\src\app\lvgl\src\libs\tiny_ttf;..\..\..\..\src\app\lvgl\src\libs\tjpgd;..\..\..\..\src\app\lvgl\src\libs\frogfs\src;..\..\..\..\src\app\lvgl\src\libs\frogfs\include\frogfs;..\..\..\..\src\app\lvgl\src\libs\gif\AnimatedGIF\src;..\..\..\..\src\app\lvgl\src\libs\gltf\fastgltf;..\..\..\..\src\app\lvgl\src\libs\gltf\gltf_data;..\..\..\..\src\app\lvgl\src\libs\gltf\gltf_view;..\..\..\..\src\app\lvgl\src\libs\gltf\math;..\..\..\..\src\app\lvgl\src\libs\gltf\stb_image;..\..\..\..\src\app\lvgl\src\libs\gltf\gltf_view\assets;..\..\..\..\src\app\lvgl\src\libs\gltf\gltf_view\ibl;..\..\..\..\src\app\lvgl\src\libs\Lite3D\include;..\..\..\..\src\app\lvgl\src\libs\thorvg\rapidjson;..\..\..\..\src\app\lvgl\src\libs\thorvg\rapidjson\error;..\..\..\..\src\app\lvgl\src\libs\thorvg\rapidjson\internal;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\inc;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\lv_vg_lite_hal;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLiteKernel;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc255\0x40A;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1215;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1216;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423;..\..\..\..\src\app\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423_ECO;..\..\..\..\src\app\lvgl\src\misc\cache;..\..\..\..\src\app\lvgl\src\misc\cache\class;..\..\..\..\src\app\lvgl\src\misc\cache\instance;..\..\..\..\src\app\lvgl\src\others\file_explorer;..\..\..\..\src\app\lvgl\src\others\font_manager;..\..\..\..\src\app\lvgl\src\others\fragment;..\..\..\..\src\app\lvgl\src\others\gridnav;..\..\..\..\src\app\lvgl\src\others\ime;..\..\..\..\src\app\lvgl\src\others\imgfont;..\..\..\..\src\app\lvgl\src\others\monkey;..\..\..\..\src\app\lvgl\src\others\observer;..\..\..\..\src\app\lvgl\src\others\snapshot;..\..\..\..\src\app\lvgl\src\others\sysmon;..\..\..\..\src\app\lvgl\src\others\test;..\..\..\..\src\app\lvgl\src\others\translation;..\..\..\..\src\app\lvgl\src\others\vg_lite_tvg;..\..\..\..\src\app\lvgl\src\others\xml;..\..\..\..\src\app\lvgl\src\others\xml\parsers;..\..\..\..\src\app\lvgl\src\stdlib\builtin;..\..\..\..\src\app\lvgl\src\themes\default;..\..\..\..\src\app\lvgl\src\themes\mono;..\..\..\..\src\app\lvgl\src\themes\simple;..\..\..\..\src\app\lvgl\src\widgets\3d;..\..\..\..\src\app\lvgl\src\widgets\3dtexture;..\..\..\..\src\app\lvgl\src\widgets\animimage;..\..\..\..\src\app\lvgl\src\widgets\arc;..\..\..\..\src\app\lvgl\src\widgets\arclabel;..\..\..\..\src\app\lvgl\src\widgets\bar;..\..\..\..\src\app\lvgl\src\widgets\button;..\..\..\..\src\app\lvgl\src\widgets\buttonmatrix;..\..\..\..\src\app\lvgl\src\widgets\calendar;..\..\..\..\src\app\lvgl\src\widgets\canvas;..\..\..\..\src\app\lvgl\src\widgets\cardview;..\..\..\..\src\app\lvgl\src\widgets\cellular;..\..\..\..\src\app\lvgl\src\widgets\chart;..\..\..\..\src\app\lvgl\src\widgets\checkbox;..\..\..\..\src\app\lvgl\src\widgets\dropdown;..\..\..\..\src\app\lvgl\src\widgets\image;..\..\..\..\src\app\lvgl\src\widgets\imagebutton;..\..\..\..\src\app\lvgl\src\widgets\keyboard;..\..\..\..\src\app\lvgl\src\widgets\label;..\..\..\..\src\app\lvgl\src\widgets\led;..\..\..\..\src\app\lvgl\src\widgets\line;..\..\..\..\src\app\lvgl\src\widgets\list;..\..\..\..\src\app\lvgl\src\widgets\lottie;..\..\..\..\src\app\lvgl\src\widgets\menu;..\..\..\..\src\app\lvgl\src\widgets\msgbox;..\..\..\..\src\app\lvgl\src\widgets\objx_templ;..\..\..\..\src\app\lvgl\src\widgets\property;..\..\..\..\src\app\lvgl\src\widgets\roller;..\..\..\..\src\app\lvgl\src\widgets\scale;..\..\..\..\src\app\lvgl\src\widgets\slider;..\..\..\..\src\app\lvgl\src\widgets\snapshot;..\..\..\..\src\app\lvgl\src\widgets\span;..\..\..\..\src\app\lvgl\src\widgets\spinbox;..\..\..\..\src\app\lvgl\src\widgets\spinner;..\..\..\..\src\app\lvgl\src\widgets\switch;..\..\..\..\src\app\lvgl\src\widgets\table;..\..\..\..\src\app\lvgl\src\widgets\tabview;..\..\..\..\src\app\lvgl\src\widgets\textarea;..\..\..\..\src\app\lvgl\src\widgets\tileview;..\..\..\..\src\app\lvgl\src\widgets\win;..\..\..\..\src\app\lvgl\examples;..\..\..\..\src\app\lvgl\examples\anim;..\..\..\..\src\app\lvgl\examples\event;..\..\..\..\src\app\lvgl\examples\get_started;..\..\..\..\src\app\lvgl\examples\grad;..\..\..\..\src\app\lvgl\examples\layouts;..\..\..\..\src\app\lvgl\examples\libs;..\..\..\..\src\app\lvgl\examples\others;..\..\..\..\src\app\lvgl\examples\porting;..\..\..\..\src\app\lvgl\examples\scroll;..\..\..\..\src\app\lvgl\examples\styles;..\..\..\..\src\app\lvgl\examples\widgets;..\..\..\..\src\app\lvgl\examples\layouts\flex;..\..\..\..\src\app\lvgl\examples\layouts\grid;..\..\..\..\src\app\lvgl\examples\libs\barcode;..\..\..\..\src\app\lvgl\examples\libs\bmp;..\..\..\..\src\app\lvgl\examples\libs\ffmpeg;..\..\..\..\src\app\lvgl\examples\libs\freetype;..\..\..\..\src\app\lvgl\examples\libs\gif;..\..\..\..\src\app\lvgl\examples\libs\gltf;..\..\..\..\src\app\lvgl\examples\libs\gstreamer;..\..\..\..\src\app\lvgl\examples\libs\libjpeg_turbo;..\..\..\..\src\app\lvgl\examples\libs\libpng;..\..\..\..\src\app\lvgl\examples\libs\lodepng;..\..\..\..\src\app\lvgl\examples\libs\qrcode;..\..\..\..\src\app\lvgl\examples\libs\rlottie;..\..\..\..\src\app\lvgl\examples\libs\svg;..\..\..\..\src\app\lvgl\examples\libs\tiny_ttf;..\..\..\..\src\app\lvgl\examples\libs\tjpgd;..\..\..\..\src\app\lvgl\examples\others\file_explorer;..\..\..\..\src\app\lvgl\examples\others\font_manager;..\..\..\..\src\app\lvgl\examples\others\fragment;..\..\..\..\src\app\lvgl\examples\others\gestures;..\..\..\..\src\app\lvgl\examples\others\gridnav;..\..\..\..\src\app\lvgl\examples\others\ime;..\..\..\..\src\app\lvgl\examples\others\imgfont;..\..\..\..\src\app\lvgl\examples\others\monkey;..\..\..\..\src\app\lvgl\examples\others\observer;..\..\..\..\src\app\lvgl\examples\others\snapshot;..\..\..\..\src\app\lvgl\examples\others\translation;..\..\..\..\src\app\lvgl\examples\others\xml;..\..\..\..\src\app\lvgl\examples\porting\osal;..\..\..\..\src\app\lvgl\demos;..\..\..\..\src\app\lvgl\demos\benchmark;..\..\..\..\src\app\lvgl\demos\gltf;..\..\..\..\src\app\lvgl\demos\keypad_encoder;..\..\..\..\src\app\lvgl\demos\music;..\..\..\..\src\app\lvgl\demos\render;..\..\..\..\src\app\lvgl\demos\stress;..\..\..\..\src\app\lvgl\demos\vector_graphic;..\..\..\..\src\app\lvgl\demos\widgets;..\..\..\..\src\app\lvgl\demos\music\assets
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\app.sct
  group app
    ../src/: main.c display_init.c
  group 8762d_device
    ../../../../bin/: ROM.lib adc.lib rtl8762d_sdk.lib
    ../../../../bin/upperstack_img/upperstack_0_0/: gap_utils.lib
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    ../../../../src/platform/: qspi_lcd_platform.c
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_pinmux.c rtl876x_rcc.c rtl876x_nvic.c rtl876x_tim.c rtl876x_io_dlps.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_uart.c rtl876x_adc.c rtl876x_spi.c rtl876x_i2c.c rtl876x_rtc.c
  group port_lvgl
    ../src/lvgl_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lvgl_demo.c
  group lcd_low_driver
    ../../../../src/app/Wearable/device/lcd/8762D/: lcd_st77916g5_320_qspi.c
  group touch_driver
    ../../../../src/app/Wearable/device/touch/8762D/: touch_cst816d.c
  group hal_drivers
    ../../../../src/app/Wearable/driver/io/: drv_flash.c drv_dlps.c drv_i2c.c drv_lcd.c drv_gpio.c drv_touch.c drv_rtc.c
  group Compiler
    ../../../../src/app/Wearable/misc/libc/compilers/armlibc/: syscalls.c
  group LVGL
    ../../../../src/app/lvgl/src/: lv_init.c
    ../../../../src/app/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../../src/app/lvgl/src/display/: lv_display.c
    ../../../../src/app/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../../src/app/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../src/app/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../../src/app/lvgl/src/layouts/: lv_layout.c
    ../../../../src/app/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../../src/app/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../../src/app/lvgl/src/stdlib/: lv_mem.c
    ../../../../src/app/lvgl/src/themes/: lv_theme.c
    ../../../../src/app/lvgl/src/tick/: lv_tick.c
    ../../../../src/app/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../../src/app/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../../../../src/app/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../../../../src/app/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../../../../src/app/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../../../../src/app/lvgl/src/draw/rtk/: font_rendering_utils.c lv_draw_rtk.c lv_draw_rtk_img.c lv_draw_rtk_letter.c
    ../../../../src/app/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../../../../src/app/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../../../src/app/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../../../../src/app/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../../src/app/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../../src/app/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../../../../src/app/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../../../../src/app/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../../../../src/app/lvgl/src/draw/ppe/rtl8773e/: lv_draw_ppe_rtl8773e.c lv_draw_ppe_rtl8773e_fill.c lv_draw_ppe_rtl8773e_img.c lv_ppe_rtl8773e_utils.c
    ../../../../src/app/lvgl/src/draw/ppe/rtl8773g/: lv_draw_ppe_rtl8773g.c lv_draw_ppe_rtl8773g_blend.c lv_draw_ppe_rtl8773g_box_shadow.c lv_draw_ppe_rtl8773g_fill.c lv_draw_ppe_rtl8773g_img.c lv_draw_ppe_rtl8773g_letter.c lv_draw_ppe_rtl8773g_mask_rect.c lv_draw_ppe_rtl8773g_support.c lv_ppe_rtl8773g_utils.c
    ../../../../src/app/lvgl/src/draw/ppe/rtl87x2g/: lv_draw_ppe_rtl87x2g.c lv_draw_ppe_rtl87x2g_fill.c lv_draw_ppe_rtl87x2g_img.c lv_ppe_rtl87x2g_utils.c
    ../../../../src/app/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../../../../src/app/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../../src/app/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../../src/app/lvgl/src/drivers/evdev/: lv_evdev.c
    ../../../../src/app/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../../../../src/app/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../../../../src/app/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../../../../src/app/lvgl/src/drivers/qnx/: lv_qnx.c
    ../../../../src/app/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../../../../src/app/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../../../../src/app/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../../../../src/app/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../../../../src/app/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../../../../src/app/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../../../../src/app/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../../../../src/app/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../../../../src/app/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../../../../src/app/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../../../../src/app/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../../../../src/app/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../../../../src/app/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../../../../src/app/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../../../../src/app/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../../../../src/app/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../../../../src/app/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../../../../src/app/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../../../../src/app/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../../../../src/app/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../../../../src/app/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
    ../../../../src/app/lvgl/src/layouts/flex/: lv_flex.c
    ../../../../src/app/lvgl/src/layouts/grid/: lv_grid.c
    ../../../../src/app/lvgl/src/libs/avi/: avidec.c lv_avi.c
    ../../../../src/app/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../../../../src/app/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../../src/app/lvgl/src/libs/bmp/: lv_bmp.c
    ../../../../src/app/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../../../../src/app/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../src/app/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../../../src/app/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../../src/app/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../../../../src/app/lvgl/src/libs/gif/: lv_gif.c
    ../../../../src/app/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../../../../src/app/lvgl/src/libs/jpu/: lv_jpu.c
    ../../../../src/app/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../../../src/app/lvgl/src/libs/libpng/: lv_libpng.c
    ../../../../src/app/lvgl/src/libs/Lite3D/: Lite3D_port_lvgl.c
    ../../../../src/app/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../../../src/app/lvgl/src/libs/lz4/: lz4.c
    ../../../../src/app/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../src/app/lvgl/src/libs/rle/: lv_idu.c lv_rle.c
    ../../../../src/app/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../../../src/app/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../../../src/app/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../../../src/app/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../../../src/app/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../../../src/app/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../../../src/app/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../../../../src/app/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../../../../src/app/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../../../../src/app/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../../../../src/app/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../../../../src/app/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../../src/app/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../../src/app/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../../src/app/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../../src/app/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../../src/app/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../../src/app/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../../../src/app/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../../../src/app/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../../../src/app/lvgl/src/others/monkey/: lv_monkey.c
    ../../../../src/app/lvgl/src/others/observer/: lv_observer.c
    ../../../../src/app/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../../src/app/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../../src/app/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../../../src/app/lvgl/src/others/translation/: lv_translation.c
    ../../../../src/app/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../../../src/app/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../../../../src/app/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../../../../src/app/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../../src/app/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../../../src/app/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../../../src/app/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../../../src/app/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../../../../src/app/lvgl/src/themes/default/: lv_theme_default.c
    ../../../../src/app/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../../src/app/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../../src/app/lvgl/src/widgets/3d/: lv_lite3d.c
    ../../../../src/app/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../../src/app/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../../src/app/lvgl/src/widgets/arc/: lv_arc.c
    ../../../../src/app/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../../src/app/lvgl/src/widgets/bar/: lv_bar.c
    ../../../../src/app/lvgl/src/widgets/button/: lv_button.c
    ../../../../src/app/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../../src/app/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../src/app/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../../src/app/lvgl/src/widgets/cardview/: lv_cardview.c
    ../../../../src/app/lvgl/src/widgets/cellular/: lv_cellular.c
    ../../../../src/app/lvgl/src/widgets/chart/: lv_chart.c
    ../../../../src/app/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../../src/app/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../../src/app/lvgl/src/widgets/image/: lv_image.c
    ../../../../src/app/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../../src/app/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../../src/app/lvgl/src/widgets/label/: lv_label.c
    ../../../../src/app/lvgl/src/widgets/led/: lv_led.c
    ../../../../src/app/lvgl/src/widgets/line/: lv_line.c
    ../../../../src/app/lvgl/src/widgets/list/: lv_list.c
    ../../../../src/app/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../../src/app/lvgl/src/widgets/menu/: lv_menu.c
    ../../../../src/app/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../../src/app/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../../src/app/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../../../src/app/lvgl/src/widgets/roller/: lv_roller.c
    ../../../../src/app/lvgl/src/widgets/scale/: lv_scale.c
    ../../../../src/app/lvgl/src/widgets/slider/: lv_slider.c
    ../../../../src/app/lvgl/src/widgets/snapshot/: lv_snapshot_widgets.c
    ../../../../src/app/lvgl/src/widgets/span/: lv_span.c
    ../../../../src/app/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../../src/app/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../../src/app/lvgl/src/widgets/switch/: lv_switch.c
    ../../../../src/app/lvgl/src/widgets/table/: lv_table.c
    ../../../../src/app/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../../src/app/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../../src/app/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../../src/app/lvgl/src/widgets/win/: lv_win.c
    ../../../../src/app/lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_4.c lv_example_anim_timeline_1.c
    ../../../../src/app/lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_argb.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c img_svg_img.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../../../../src/app/lvgl/examples/event/: lv_example_event_bubble.c lv_example_event_button.c lv_example_event_click.c lv_example_event_draw.c lv_example_event_streak.c lv_example_event_trickle.c
    ../../../../src/app/lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_4.c
    ../../../../src/app/lvgl/examples/grad/: lv_example_grad_1.c lv_example_grad_2.c lv_example_grad_3.c lv_example_grad_4.c
    ../../../../src/app/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
    ../../../../src/app/lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c lv_example_scroll_7.c lv_example_scroll_8.c
    ../../../../src/app/lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_16.c lv_example_style_17.c lv_example_style_18.c lv_example_style_19.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
    ../../../../src/app/lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../../../../src/app/lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
    ../../../../src/app/lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
    ../../../../src/app/lvgl/examples/libs/barcode/: lv_example_barcode_1.c
    ../../../../src/app/lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../../../../src/app/lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../../../../src/app/lvgl/examples/libs/freetype/: lv_example_freetype_1.c lv_example_freetype_2.c lv_example_freetype_3.c
    ../../../../src/app/lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    ../../../../src/app/lvgl/examples/libs/gltf/: lv_example_gltf_1.c lv_example_gltf_2.c
    ../../../../src/app/lvgl/examples/libs/gstreamer/: lv_example_gstreamer_1.c
    ../../../../src/app/lvgl/examples/libs/libjpeg_turbo/: lv_example_libjpeg_turbo_1.c
    ../../../../src/app/lvgl/examples/libs/libpng/: img_png_demo.c lv_example_libpng_1.c
    ../../../../src/app/lvgl/examples/libs/lodepng/: img_wink_png.c lv_example_lodepng_1.c
    ../../../../src/app/lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
    ../../../../src/app/lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../../../../src/app/lvgl/examples/libs/svg/: lv_example_svg_1.c lv_example_svg_2.c lv_example_svg_3.c
    ../../../../src/app/lvgl/examples/libs/tiny_ttf/: lv_example_tiny_ttf_1.c lv_example_tiny_ttf_2.c lv_example_tiny_ttf_3.c ubuntu_font.c
    ../../../../src/app/lvgl/examples/libs/tjpgd/: lv_example_tjpgd_1.c
    ../../../../src/app/lvgl/examples/others/file_explorer/: lv_example_file_explorer_1.c lv_example_file_explorer_2.c lv_example_file_explorer_3.c
    ../../../../src/app/lvgl/examples/others/font_manager/: lv_example_font_manager_1.c lv_example_font_manager_2.c lv_example_font_manager_3.c
    ../../../../src/app/lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../../../../src/app/lvgl/examples/others/gestures/: lv_example_gestures.c
    ../../../../src/app/lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c lv_example_gridnav_5.c
    ../../../../src/app/lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../../../../src/app/lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../../../../src/app/lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../../../../src/app/lvgl/examples/others/observer/: lv_example_observer_1.c lv_example_observer_2.c lv_example_observer_3.c lv_example_observer_4.c lv_example_observer_5.c lv_example_observer_6.c lv_example_observer_7.c
    ../../../../src/app/lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../../../../src/app/lvgl/examples/others/translation/: lv_example_translation_1.c lv_example_translation_2.c
    ../../../../src/app/lvgl/examples/others/xml/: lv_example_xml_1.c lv_example_xml_2.c
    ../../../../src/app/lvgl/examples/porting/osal/: lv_example_osal.c
    ../../../../src/app/lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
    ../../../../src/app/lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c lv_example_arc_3.c
    ../../../../src/app/lvgl/examples/widgets/arclabel/: lv_example_arclabel_1.c
    ../../../../src/app/lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c lv_example_bar_7.c
    ../../../../src/app/lvgl/examples/widgets/button/: lv_example_button_1.c lv_example_button_2.c lv_example_button_3.c
    ../../../../src/app/lvgl/examples/widgets/buttonmatrix/: lv_example_buttonmatrix_1.c lv_example_buttonmatrix_2.c lv_example_buttonmatrix_3.c
    ../../../../src/app/lvgl/examples/widgets/calendar/: lv_example_calendar_1.c lv_example_calendar_2.c
    ../../../../src/app/lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_10.c lv_example_canvas_11.c lv_example_canvas_2.c lv_example_canvas_3.c lv_example_canvas_4.c lv_example_canvas_5.c lv_example_canvas_6.c lv_example_canvas_7.c lv_example_canvas_8.c lv_example_canvas_9.c
    ../../../../src/app/lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c
    ../../../../src/app/lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    ../../../../src/app/lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    ../../../../src/app/lvgl/examples/widgets/image/: lv_example_image_1.c lv_example_image_2.c lv_example_image_3.c lv_example_image_4.c lv_example_image_5.c
    ../../../../src/app/lvgl/examples/widgets/imagebutton/: lv_example_imagebutton_1.c
    ../../../../src/app/lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c lv_example_keyboard_2.c lv_example_keyboard_3.c
    ../../../../src/app/lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c lv_example_label_6.c lv_example_label_7.c
    ../../../../src/app/lvgl/examples/widgets/led/: lv_example_led_1.c
    ../../../../src/app/lvgl/examples/widgets/line/: lv_example_line_1.c
    ../../../../src/app/lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    ../../../../src/app/lvgl/examples/widgets/lottie/: lv_example_lottie_1.c lv_example_lottie_2.c lv_example_lottie_approve.c
    ../../../../src/app/lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
    ../../../../src/app/lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c lv_example_msgbox_2.c
    ../../../../src/app/lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c lv_example_obj_3.c
    ../../../../src/app/lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
    ../../../../src/app/lvgl/examples/widgets/scale/: lv_example_scale_1.c lv_example_scale_10.c lv_example_scale_11.c lv_example_scale_12.c lv_example_scale_2.c lv_example_scale_3.c lv_example_scale_4.c lv_example_scale_5.c lv_example_scale_6.c lv_example_scale_7.c lv_example_scale_8.c lv_example_scale_9.c
    ../../../../src/app/lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c lv_example_slider_4.c
    ../../../../src/app/lvgl/examples/widgets/span/: lv_example_span_1.c
    ../../../../src/app/lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
    ../../../../src/app/lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
    ../../../../src/app/lvgl/examples/widgets/switch/: lv_example_switch_1.c lv_example_switch_2.c
    ../../../../src/app/lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    ../../../../src/app/lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    ../../../../src/app/lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c lv_example_textarea_4.c
    ../../../../src/app/lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
    ../../../../src/app/lvgl/examples/widgets/win/: lv_example_win_1.c
    ../../../../src/app/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../../src/app/lvgl/demos/gltf/: lv_demo_gltf.c
    ../../../../src/app/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../../../../src/app/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../../../src/app/lvgl/demos/render/: lv_demo_render.c
    ../../../../src/app/lvgl/demos/stress/: lv_demo_stress.c
    ../../../../src/app/lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
    ../../../../src/app/lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../../../../src/app/lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../../../../src/app/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../../../src/app/lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_argb8888_premultiplied.c img_render_lvgl_logo_i1.c img_render_lvgl_logo_l8.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb565_swapped.c img_render_lvgl_logo_rgb565a8.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
    ../../../../src/app/lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
    ../../../../src/app/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
