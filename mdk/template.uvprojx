# Keil uVision project template.uvprojx, settings and files
target dashboard_dual_bank0 (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  BeforeMake: bash ..\..\..\..\tool\Gadgets\version_gen_config.sh ../version.h
  BeforeMake: cmd.exe /c rtl87x3ep_before_build_script.bat 16M rtl87x3ep all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3ep
  c flags: Optim=3 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: DLPS_EN = 0 TEMP_BUILD_OS_IN_NS_ROM
  c misc: --include pre_define.h  --include stdbool.h --include app_flags.h
  c include: ..\..\..\..\inc\os\freertos;..\..\..\..\inc\os\osif;..\..\..\..\src\os\freertos\portable\GCC\ARM_CM33\non_secure;..\..\..\..\inc\mcu\rtl8762x;..\..\..\..\inc\platform;..\..\..\..\inc\platform\cmsis\Core\Include;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\peripheral;..\..\..\..\src\app\template;..\;..\..\..\..\..\os\osif\inc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\cfg\rtl87x3ep\rtl87x3ep_hmi_bank0.sct
target dashboard_dual_bank1 (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: app_ns +hex
  BeforeMake: as above
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_16M_dualbank rtl87x3ep
  c flags: Optim=3 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: DLPS_EN = 0 TEMP_BUILD_OS_IN_NS_ROM
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\cfg\rtl87x3ep\rtl87x3ep_hmi_bank1.sct
software components: CMSIS:CORE 5.6.0
