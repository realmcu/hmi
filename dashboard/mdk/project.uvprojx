# Keil uVision project project.uvprojx, settings and files
target gui (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  BeforeMake: bash ..\..\..\..\tool\Gadgets\version_gen_config.sh
  BeforeMake: cmd.exe /c rtl87x3ep_before_build_script.bat 16M rtl87x3ep all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3ep
  c flags: Optim=3 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: DEFINE_RTK_BT_TODO, DRV_LCD_HEIGHT=480, DRV_PIXEL_BITS=16, CONFIG_SOC_SERIES_RTL8773E=1, RTK_HAL_DRIVER, DRV_LCD_WIDTH=480, ENABLE_HONEYGUI, TARGET_RTL8773E, SUPPORT_ACCESS_SHM = 1
  c misc: --include pre_define.h  --include stdbool.h --include app_flags.h
  c include: ..;..;..\src\application;..\src\application;..\..\..\..\..\src\sample\gui\example\application\hml_designer;..\..\..\..\..\src\sample\gui\example\widget\glass_effect;..\..\..\..\..\src\sample\gui\example\widget\glass_effect\root_image;..\..\..\..\..\src\sample\gui\example\widget\image;..\..\..\..\..\src\sample\gui\example\widget\particle;..\..\..\..\..\src\sample\gui\example\widget\particle\root_image;..\..\..\..\..\src\sample\gui\realgui\widget\gui_particle\effects;..\..\..\..\..\src\sample\gui\example\widget\video;..\..\..\..\..\src\sample\gui\example\widget\video\root_image;..\..\..\..\..\inc\app;..\..\..\..\..\inc\os;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\rtl87x3ep\platform;..\..\..\..\..\inc\rtl87x3ep\hal;..\..\..\..\..\bin\rtl87x3ep\upperstack_stamp;..\..\..\..\..\bin\rtl87x3ep\flash_map_config\16M\flash_16M;..\..\..\..\..\src\mcu\display\hardware;..\..\..\..\..\src\mcu\display\hardware\idu\inc;..\..\..\..\..\src\mcu\display\hardware\idu\src\device\rtl8773e;..\..\..\..\..\src\mcu\display\hardware\lcdc\inc;..\..\..\..\..\src\mcu\display\hardware\lcdc\src\device\rtl8773e;..\..\..\..\..\src\mcu\display\hardware\ppe\src\device\rtl8773e;..\..\..\..\..\src\mcu\display\hardware\ppe\inc\rtl8773e;..\..\..\..\..\inc\hal\platform;..\..\..\..\..\inc\hal\io;..\..\..\..\..\inc\rtl87x3ep\io;..\..\..\..\..\inc\os\FreeRTOS;..\..\..\..\..\src\sample\gui\realgui;..\..\..\..\..\src\sample\gui\realgui\3rd;..\..\..\..\..\src\sample\gui\realgui\3rd\cgltf;..\..\..\..\..\src\sample\gui\realgui\3rd\gifdec;..\..\..\..\..\src\sample\gui\realgui\3rd\nanosvg;..\..\..\..\..\src\sample\gui\realgui\3rd\nanosvg\src;..\..\..\..\..\src\sample\gui\realgui\3rd\nanovg;..\..\..\..\..\src\sample\gui\realgui\3rd\nanovg\agge;..\..\..\..\..\src\sample\gui\realgui\3rd\nanovg\base;..\..\..\..\..\src\sample\gui\realgui\3rd\stb;..\..\..\..\..\src\sample\gui\realgui\3rd\tinyobj;..\..\..\..\..\src\sample\gui\realgui\3rd\tjpgd;..\..\..\..\..\src\sample\gui\realgui\core;..\..\..\..\..\src\sample\gui\realgui\dc;..\..\..\..\..\src\sample\gui\realgui\engine;..\..\..\..\..\src\sample\gui\realgui\engine\accel_hal;..\..\..\..\..\src\sample\gui\realgui\engine\blit;..\..\..\..\..\src\sample\gui\realgui\engine\blit\color;..\..\..\..\..\src\sample\gui\realgui\engine\codec;..\..\..\..\..\src\sample\gui\realgui\engine\codec\idu;..\..\..\..\..\src\sample\gui\realgui\engine\codec\jpeg;..\..\..\..\..\src\sample\gui\realgui\engine\codec\rle;..\..\..\..\..\src\sample\gui\realgui\engine\draw;..\..\..\..\..\src\sample\gui\realgui\engine\font;..\..\..\..\..\src\sample\gui\realgui\engine\post_process;..\..\..\..\..\src\sample\gui\realgui\input;..\..\..\..\..\src\sample\gui\realgui\misc;..\..\..\..\..\src\sample\gui\realgui\misc\tlsf;..\..\..\..\..\src\sample\gui\realgui\misc\vfs;..\..\..\..\..\src\sample\gui\realgui\misc\vfs\romfs;..\..\..\..\..\src\sample\gui\realgui\server;..\..\..\..\..\src\sample\gui\realgui\widget;..\..\..\..\..\src\sample\gui\realgui\widget\gui_canvas;..\..\..\..\..\src\sample\gui\realgui\widget\gui_geometry;..\..\..\..\..\src\sample\gui\realgui\widget\gui_gif;..\..\..\..\..\src\sample\gui\realgui\widget\gui_glass;..\..\..\..\..\src\sample\gui\realgui\widget\gui_gray;..\..\..\..\..\src\sample\gui\realgui\widget\gui_img;..\..\..\..\..\src\sample\gui\realgui\widget\gui_list;..\..\..\..\..\src\sample\gui\realgui\widget\gui_lottie;..\..\..\..\..\src\sample\gui\realgui\widget\gui_menu_cellular;..\..\..\..\..\src\sample\gui\realgui\widget\gui_obj;..\..\..\..\..\src\sample\gui\realgui\widget\gui_qbcode;..\..\..\..\..\src\sample\gui\realgui\widget\gui_soccer;..\..\..\..\..\src\sample\gui\realgui\widget\gui_svg;..\..\..\..\..\src\sample\gui\realgui\widget\gui_text;..\..\..\..\..\src\sample\gui\realgui\widget\gui_video;..\..\..\..\..\src\sample\gui\realgui\widget\gui_view;..\..\..\..\..\src\sample\gui\realgui\widget\gui_win;..\src\ports\realgui_port;..\..\..\..\..\src\app\Wearable\audio\music_player;..\..\..\..\..\src\app\Wearable\communicate\rtk_bt;..\..\..\..\..\src\app\Wearable\device\key_button\8773E;..\..\..\..\..\src\app\Wearable\device\knob\8773E;..\..\..\..\..\src\app\Wearable\device\lcd\8762G;..\..\..\..\..\src\app\Wearable\device\lcd\8772F;..\..\..\..\..\src\app\Wearable\device\lcd\8773E;..\..\..\..\..\src\app\Wearable\device\touch\8762G;..\..\..\..\..\src\app\Wearable\device\touch\8773E;..\..\..\..\..\src\app\Wearable\driver\io;..\..\..\..\..\src\app\Wearable\system\clock;..\..\..\..\..\src\app\Wearable\system\dfs\romfs
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\ac6.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group app
    ../: menu_config.h mem_config.h board.h config.h
    ../src/application/: app_flags.h app_lower_init.c app_panel_init.c main.c
  group realgui/demo
    ../../../../../src/sample/gui/example/widget/image/: example_img.c
  group RTK_BSP
    ../src/bsp/: startup_rtl.c system_rtl87x3.c
    ../../../../../bin/rtl87x3ep/: ROM.lib upperstack_4M.lib hal_utils.lib
    ../../../../../src/mcu/display/hardware/ppe/src/device/rtl8773e/: rtl_ppe.c
    ../../../../../src/mcu/display/hardware/idu/src/device/rtl8773e/: rtl_idu_int.c
    ../../../../../src/mcu/display/hardware/idu/src/device/rtl_common/: rtl_idu.c
    ../../../../../src/mcu/display/hardware/lcdc/src/device/rtl_common/: rtl_lcdc.c rtl_lcdc_dbic.c rtl_lcdc_dbib.c rtl_lcdc_edpi.c
    ../../../../../src/mcu/display/bindings/honeygui/hardware_engine/PPE/rtl8773e/: acc_ppe.c
  group 3rd
    ../../../../../src/sample/gui/realgui/3rd/gifdec/: gifdec.c
    ../../../../../src/sample/gui/realgui/3rd/nanovg/agge/: math.cpp nanovg_agge.cpp nanovg_vertex.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../../../../../src/sample/gui/realgui/3rd/nanovg/base/: nanovg.c nanovg_port.c
    ../../../../../src/sample/gui/realgui/3rd/stb/: stb_image.cpp
    ../../../../../src/sample/gui/realgui/3rd/tjpgd/: tjpgd.c
  group core
    ../../../../../src/sample/gui/realgui/core/: gui_math.c gui_matrix.c
  group dc
    ../../../../../src/sample/gui/realgui/dc/: gui_fb.c
  group engine
    ../../../../../src/sample/gui/realgui/engine/accel_hal/: acc_api.c
    ../../../../../src/sample/gui/realgui/engine/blit/: acc_sw.c acc_sw_arm2d_blur.c acc_sw_raster.c
    ../../../../../src/sample/gui/realgui/engine/blit/color/: a8_2_a8.c a8_2_rgb565.c argb8565_2_rgb565.c rgb565_2_rgb565.c
    ../../../../../src/sample/gui/realgui/engine/codec/idu/: acc_sw_idu.c
    ../../../../../src/sample/gui/realgui/engine/codec/jpeg/: acc_sw_jpeg.c
    ../../../../../src/sample/gui/realgui/engine/codec/rle/: acc_sw_rle.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
    ../../../../../src/sample/gui/realgui/engine/draw/: draw_font.c draw_img.c
    ../../../../../src/sample/gui/realgui/engine/font/: font_custom.c font_lib_manager.c font_mem.c font_mem_img.c font_mem_matrix.c font_rendering_utils.c font_stb.c font_ttf.c
    ../../../../../src/sample/gui/realgui/engine/post_process/: gui_post_process.c
  group input
    ../../../../../src/sample/gui/realgui/input/: kb_algo.c tp_algo.c wheel_algo.c
  group misc
    ../../../../../src/sample/gui/realgui/misc/tlsf/: tlsf.c
    ../../../../../src/sample/gui/realgui/misc/vfs/: gui_vfs.c gui_vfs_generic.c gui_vfs_posix.c gui_vfs_ramfs.c gui_vfs_romfs.c
    ../../../../../src/sample/gui/realgui/misc/vfs/romfs/: hg_romfs.c
  group server
    ../../../../../src/sample/gui/realgui/server/: gui_api_acc.c gui_api_audio.c gui_api_color.c gui_api_dc.c gui_api_ftl.c gui_api_indev.c gui_api_os.c gui_components_init.c gui_listener.c gui_message.c gui_pm.c gui_server.c
  group widget
    ../../../../../src/sample/gui/realgui/widget/gui_canvas/: gui_canvas.c gui_canvas_img.c
    ../../../../../src/sample/gui/realgui/widget/gui_geometry/: gui_arc.c gui_arc_group.c gui_circle.c gui_rect.c lite_geometry.c lite_geometry_math.c
    ../../../../../src/sample/gui/realgui/widget/gui_gif/: gui_gif.c
    ../../../../../src/sample/gui/realgui/widget/gui_glass/: gui_glass.c
    ../../../../../src/sample/gui/realgui/widget/gui_img/: gui_img.c gui_img_api.c
    ../../../../../src/sample/gui/realgui/widget/gui_list/: gui_list.c gui_list_rotate_curl.c gui_list_rotate_helix.c
    ../../../../../src/sample/gui/realgui/widget/gui_lottie/: gui_lottie.c
    ../../../../../src/sample/gui/realgui/widget/gui_menu_cellular/: gui_menu_cellular.c
    ../../../../../src/sample/gui/realgui/widget/gui_obj/: gui_obj.c gui_obj_event.c gui_obj_focus.c gui_obj_suppress.c gui_obj_timer.c gui_obj_tree.c
    ../../../../../src/sample/gui/realgui/widget/gui_qbcode/: gui_barcode_gen.c gui_qbcode.c gui_qrcode_gen.c
    ../../../../../src/sample/gui/realgui/widget/gui_soccer/: gui_soccer.c
    ../../../../../src/sample/gui/realgui/widget/gui_svg/: gui_svg.c
    ../../../../../src/sample/gui/realgui/widget/gui_text/: gui_scroll_text.c gui_text.c
    ../../../../../src/sample/gui/realgui/widget/gui_video/: gui_video.c
    ../../../../../src/sample/gui/realgui/widget/gui_view/: gui_view.c gui_view_animate.c gui_view_blur.c gui_view_cube.c gui_view_descriptor.c gui_view_reduction.c gui_view_rotate.c gui_view_translation.c
    ../../../../../src/sample/gui/realgui/widget/gui_win/: gui_win.c
  group realgui/port
    ../src/ports/realgui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_indev.c gui_port_os.c
  group key_button
    ../../../../../src/app/Wearable/device/key_button/8773E/: key_button_8773e.c
  group lcd_low_driver
    ../../../../../src/app/Wearable/device/lcd/8773E/: lcd_sh8601z_410_502_qspi.c
  group touch_driver
    ../../../../../src/app/Wearable/device/touch/8773E/: touch_CHSC6417.c
  group fs
    ../../../../../src/app/Wearable/system/dfs/romfs/: romfs.c
software components: CMSIS:CORE 5.5.0
