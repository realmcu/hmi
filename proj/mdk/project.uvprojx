# Keil uVision project project.uvprojx, settings and files
target lvgl (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  BeforeMake: bash ..\..\..\..\tools\version_generation\version_gen_config.sh ..\version.h
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: RTK_HAL_LCD, LV_LVGL_H_INCLUDE_SIMPLE, RTK_HAL_GPIO, RTK_HAL_TOUCH = "1", RTK_HAL_FLASH, RTK_HAL_DLPS, LV_CONF_INCLUDE_SIMPLE, LV_KCONFIG_IGNORE, ENABLE_LVGL_GUI, RTK_HAL_I2C, RTL87x2G, RTK_HAL_DRIVER, CONFIG_SOC_SERIES_RTL87X2G
  c misc: -Wno-implicit-function-declaration -gdwarf-3
  c include: ..;..;..\..\..\..\include\rtl87x2g;..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\include\rtl87x2g\secure;..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\include\rtl87x2g\config;..\..\..\..\subsys\osif\inc;..\..\..\..\subsys\display\bindings;..\..\..\..\subsys\display\hardware\lcdc\inc;..\..\..\..\subsys\display\hardware\lcdc\src\device\rtl87x2g;..\..\..\..\subsys\display\device\general\lcd;..\..\..\..\subsys\display\device\general\touch;..\..\..\..\subsys\lvgl;..\..\src\application;..\..\src\dlps;..\..\src\lvglv9_port;..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\include\rtl87x2g;..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\include\rtl87x2g;..\..\..\..\subsys\bluetooth\gap_ext\lib\rtl87x2g;..\..\..\..\include\rtl87x2g\secure;..\..\..\..\include\rtl87x2g\secure;..\..\..\..\bsp\boot\rtl87x2g;..\..\..\..\bsp\driver;..\..\..\..\bsp\driver\adc\inc;..\..\..\..\bsp\driver\can\inc;..\..\..\..\bsp\driver\codec\src\rtl87x2g;..\..\..\..\bsp\driver\dma\inc;..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\bsp\driver\i2s\inc;..\..\..\..\bsp\driver\ir\inc;..\..\..\..\bsp\driver\iso8716\inc;..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\bsp\driver\spi\inc;..\..\..\..\bsp\driver\spi3w\inc;..\..\..\..\bsp\driver\tim\inc;..\..\..\..\bsp\driver\uart\inc;..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\bsp\driver\driver_lib\lib\rtl87x2g\inc;..\..\..\..\bsp\power;..\..\..\..\subsys\display;..\..\..\..\subsys\display\hardware\lcdc\inc;..\..\..\..\subsys\display\hardware\lcdc\src\device\rtl87x2g;..\..\..\..\subsys\display\hardware\idu\inc;..\..\..\..\subsys\display\hardware\idu\src\device\rtl87x2g;..\..\..\..\subsys\display\hardware\idu\inc;..\..\..\..\subsys\display\hardware\mipi\inc;..\..\..\..\subsys\display\hardware\ppe\inc\rtl87x2g;..\..\..\..\subsys\display\hardware\ppe\src\device\rtl87x2g;..\..\..\..\subsys\display\hardware\segcom\inc;..\..\..\..\subsys\display\hardware\jpu\inc;..\..\..\..\subsys\display\hardware\jpu\src\device\rtl87x2g;..\..\..\..\subsys\osif\freertos;..\..\..\..\subsys\osif\rtt;..\..\..\..\subsys\osif;..\..\..\..\subsys\osif\inc;..\..\..\..\subsys\osif\zephyr;..\..\..\..\subsys\bluetooth\bt_host\inc;..\..\..\..\subsys\display\device\general\lcd\8762G;..\..\..\..\subsys\display\device\general\touch\8762G;..\..\..\..\subsys\lvgl;..\..\..\..\subsys\lvgl\src;..\..\..\..\subsys\lvgl\src\core;..\..\..\..\subsys\lvgl\src\display;..\..\..\..\subsys\lvgl\src\draw;..\..\..\..\subsys\lvgl\src\drivers;..\..\..\..\subsys\lvgl\src\font;..\..\..\..\subsys\lvgl\src\indev;..\..\..\..\subsys\lvgl\src\layouts;..\..\..\..\subsys\lvgl\src\misc;..\..\..\..\subsys\lvgl\src\osal;..\..\..\..\subsys\lvgl\src\stdlib;..\..\..\..\subsys\lvgl\src\themes;..\..\..\..\subsys\lvgl\src\tick;..\..\..\..\subsys\lvgl\src\draw\convert;..\..\..\..\subsys\lvgl\src\draw\dma2d;..\..\..\..\subsys\lvgl\src\draw\eve;..\..\..\..\subsys\lvgl\src\draw\nema_gfx;..\..\..\..\subsys\lvgl\src\draw\opengles;..\..\..\..\subsys\lvgl\src\draw\rtk;..\..\..\..\subsys\lvgl\src\draw\sdl;..\..\..\..\subsys\lvgl\src\draw\sw;..\..\..\..\subsys\lvgl\src\draw\vg_lite;..\..\..\..\subsys\lvgl\src\draw\convert\helium;..\..\..\..\subsys\lvgl\src\draw\convert\neon;..\..\..\..\subsys\lvgl\src\draw\espressif\ppa;..\..\..\..\subsys\lvgl\src\draw\nxp\g2d;..\..\..\..\subsys\lvgl\src\draw\nxp\pxp;..\..\..\..\subsys\lvgl\src\draw\ppe\rtl8773e;..\..\..\..\subsys\lvgl\src\draw\ppe\rtl8773g;..\..\..\..\subsys\lvgl\src\draw\ppe\rtl87x2g;..\..\..\..\subsys\lvgl\src\draw\renesas\dave2d;..\..\..\..\subsys\lvgl\src\draw\sw\arm2d;..\..\..\..\subsys\lvgl\src\draw\sw\blend;..\..\..\..\subsys\lvgl\src\draw\sw\blend\arm2d;..\..\..\..\subsys\lvgl\src\draw\sw\blend\helium;..\..\..\..\subsys\lvgl\src\draw\sw\blend\neon;..\..\..\..\subsys\lvgl\src\drivers\evdev;..\..\..\..\subsys\lvgl\src\drivers\libinput;..\..\..\..\subsys\lvgl\src\drivers\nuttx;..\..\..\..\subsys\lvgl\src\drivers\opengles;..\..\..\..\subsys\lvgl\src\drivers\qnx;..\..\..\..\subsys\lvgl\src\drivers\sdl;..\..\..\..\subsys\lvgl\src\drivers\uefi;..\..\..\..\subsys\lvgl\src\drivers\wayland;..\..\..\..\subsys\lvgl\src\drivers\windows;..\..\..\..\subsys\lvgl\src\drivers\x11;..\..\..\..\subsys\lvgl\src\drivers\display\drm;..\..\..\..\subsys\lvgl\src\drivers\display\fb;..\..\..\..\subsys\lvgl\src\drivers\display\ft81x;..\..\..\..\subsys\lvgl\src\drivers\display\ili9341;..\..\..\..\subsys\lvgl\src\drivers\display\lcd;..\..\..\..\subsys\lvgl\src\drivers\display\lovyan_gfx;..\..\..\..\subsys\lvgl\src\drivers\display\nv3007;..\..\..\..\subsys\lvgl\src\drivers\display\nxp_elcdif;..\..\..\..\subsys\lvgl\src\drivers\display\renesas_glcdc;..\..\..\..\subsys\lvgl\src\drivers\display\st7735;..\..\..\..\subsys\lvgl\src\drivers\display\st7789;..\..\..\..\subsys\lvgl\src\drivers\display\st7796;..\..\..\..\subsys\lvgl\src\drivers\display\st_ltdc;..\..\..\..\subsys\lvgl\src\drivers\display\tft_espi;..\..\..\..\subsys\lvgl\src\drivers\draw\eve;..\..\..\..\subsys\lvgl\src\drivers\opengles\assets;..\..\..\..\subsys\lvgl\src\drivers\opengles\opengl_shader;..\..\..\..\subsys\lvgl\src\drivers\opengles\glad\include\EGL;..\..\..\..\subsys\lvgl\src\drivers\opengles\glad\include\glad;..\..\..\..\subsys\lvgl\src\drivers\opengles\glad\include\KHR;..\..\..\..\subsys\lvgl\src\layouts\flex;..\..\..\..\subsys\lvgl\src\layouts\grid;..\..\..\..\subsys\lvgl\src\libs\avi;..\..\..\..\subsys\lvgl\src\libs\barcode;..\..\..\..\subsys\lvgl\src\libs\bin_decoder;..\..\..\..\subsys\lvgl\src\libs\bmp;..\..\..\..\subsys\lvgl\src\libs\expat;..\..\..\..\subsys\lvgl\src\libs\ffmpeg;..\..\..\..\subsys\lvgl\src\libs\freetype;..\..\..\..\subsys\lvgl\src\libs\fsdrv;..\..\..\..\subsys\lvgl\src\libs\FT800-FT813;..\..\..\..\subsys\lvgl\src\libs\gif;..\..\..\..\subsys\lvgl\src\libs\gstreamer;..\..\..\..\subsys\lvgl\src\libs\jpu;..\..\..\..\subsys\lvgl\src\libs\libjpeg_turbo;..\..\..\..\subsys\lvgl\src\libs\libpng;..\..\..\..\subsys\lvgl\src\libs\lodepng;..\..\..\..\subsys\lvgl\src\libs\lz4;..\..\..\..\subsys\lvgl\src\libs\qrcode;..\..\..\..\subsys\lvgl\src\libs\rle;..\..\..\..\subsys\lvgl\src\libs\rlottie;..\..\..\..\subsys\lvgl\src\libs\svg;..\..\..\..\subsys\lvgl\src\libs\thorvg;..\..\..\..\subsys\lvgl\src\libs\tiny_ttf;..\..\..\..\subsys\lvgl\src\libs\tjpgd;..\..\..\..\subsys\lvgl\src\libs\frogfs\src;..\..\..\..\subsys\lvgl\src\libs\frogfs\include\frogfs;..\..\..\..\subsys\lvgl\src\libs\gif\AnimatedGIF\src;..\..\..\..\subsys\lvgl\src\libs\gltf\fastgltf;..\..\..\..\subsys\lvgl\src\libs\gltf\gltf_data;..\..\..\..\subsys\lvgl\src\libs\gltf\gltf_view;..\..\..\..\subsys\lvgl\src\libs\gltf\math;..\..\..\..\subsys\lvgl\src\libs\gltf\stb_image;..\..\..\..\subsys\lvgl\src\libs\gltf\gltf_view\assets;..\..\..\..\subsys\lvgl\src\libs\gltf\gltf_view\ibl;..\..\..\..\subsys\lvgl\src\libs\Lite3D\include;..\..\..\..\subsys\lvgl\src\libs\thorvg\rapidjson;..\..\..\..\subsys\lvgl\src\libs\thorvg\rapidjson\error;..\..\..\..\subsys\lvgl\src\libs\thorvg\rapidjson\internal;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\inc;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\lv_vg_lite_hal;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLiteKernel;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc255\0x40A;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1215;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc355\0x0_1216;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423;..\..\..\..\subsys\lvgl\src\libs\vg_lite_driver\VGLite\Series\gc555\0x423_ECO;..\..\..\..\subsys\lvgl\src\misc\cache;..\..\..\..\subsys\lvgl\src\misc\cache\class;..\..\..\..\subsys\lvgl\src\misc\cache\instance;..\..\..\..\subsys\lvgl\src\others\file_explorer;..\..\..\..\subsys\lvgl\src\others\font_manager;..\..\..\..\subsys\lvgl\src\others\fragment;..\..\..\..\subsys\lvgl\src\others\gridnav;..\..\..\..\subsys\lvgl\src\others\ime;..\..\..\..\subsys\lvgl\src\others\imgfont;..\..\..\..\subsys\lvgl\src\others\monkey;..\..\..\..\subsys\lvgl\src\others\observer;..\..\..\..\subsys\lvgl\src\others\snapshot;..\..\..\..\subsys\lvgl\src\others\sysmon;..\..\..\..\subsys\lvgl\src\others\test;..\..\..\..\subsys\lvgl\src\others\translation;..\..\..\..\subsys\lvgl\src\others\vg_lite_tvg;..\..\..\..\subsys\lvgl\src\others\xml;..\..\..\..\subsys\lvgl\src\others\xml\parsers;..\..\..\..\subsys\lvgl\src\stdlib\builtin;..\..\..\..\subsys\lvgl\src\themes\default;..\..\..\..\subsys\lvgl\src\themes\mono;..\..\..\..\subsys\lvgl\src\themes\simple;..\..\..\..\subsys\lvgl\src\widgets\3d;..\..\..\..\subsys\lvgl\src\widgets\3dtexture;..\..\..\..\subsys\lvgl\src\widgets\animimage;..\..\..\..\subsys\lvgl\src\widgets\arc;..\..\..\..\subsys\lvgl\src\widgets\arclabel;..\..\..\..\subsys\lvgl\src\widgets\bar;..\..\..\..\subsys\lvgl\src\widgets\button;..\..\..\..\subsys\lvgl\src\widgets\buttonmatrix;..\..\..\..\subsys\lvgl\src\widgets\calendar;..\..\..\..\subsys\lvgl\src\widgets\canvas;..\..\..\..\subsys\lvgl\src\widgets\cardview;..\..\..\..\subsys\lvgl\src\widgets\cellular;..\..\..\..\subsys\lvgl\src\widgets\chart;..\..\..\..\subsys\lvgl\src\widgets\checkbox;..\..\..\..\subsys\lvgl\src\widgets\dropdown;..\..\..\..\subsys\lvgl\src\widgets\image;..\..\..\..\subsys\lvgl\src\widgets\imagebutton;..\..\..\..\subsys\lvgl\src\widgets\keyboard;..\..\..\..\subsys\lvgl\src\widgets\label;..\..\..\..\subsys\lvgl\src\widgets\led;..\..\..\..\subsys\lvgl\src\widgets\line;..\..\..\..\subsys\lvgl\src\widgets\list;..\..\..\..\subsys\lvgl\src\widgets\lottie;..\..\..\..\subsys\lvgl\src\widgets\menu;..\..\..\..\subsys\lvgl\src\widgets\msgbox;..\..\..\..\subsys\lvgl\src\widgets\objx_templ;..\..\..\..\subsys\lvgl\src\widgets\property;..\..\..\..\subsys\lvgl\src\widgets\roller;..\..\..\..\subsys\lvgl\src\widgets\scale;..\..\..\..\subsys\lvgl\src\widgets\slider;..\..\..\..\subsys\lvgl\src\widgets\snapshot;..\..\..\..\subsys\lvgl\src\widgets\span;..\..\..\..\subsys\lvgl\src\widgets\spinbox;..\..\..\..\subsys\lvgl\src\widgets\spinner;..\..\..\..\subsys\lvgl\src\widgets\switch;..\..\..\..\subsys\lvgl\src\widgets\table;..\..\..\..\subsys\lvgl\src\widgets\tabview;..\..\..\..\subsys\lvgl\src\widgets\textarea;..\..\..\..\subsys\lvgl\src\widgets\tileview;..\..\..\..\subsys\lvgl\src\widgets\win;..\..\..\..\subsys\lvgl\demos;..\..\..\..\subsys\lvgl\demos;..\..\..\..\subsys\lvgl\demos\benchmark;..\..\..\..\subsys\lvgl\demos\gltf;..\..\..\..\subsys\lvgl\demos\keypad_encoder;..\..\..\..\subsys\lvgl\demos\music;..\..\..\..\subsys\lvgl\demos\music\assets;..\..\..\..\subsys\lvgl\demos\render;..\..\..\..\subsys\lvgl\demos\stress;..\..\..\..\subsys\lvgl\demos\vector_graphic;..\..\..\..\subsys\lvgl\demos\widgets;..\..\..\..\subsys\wearable\driver\io
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group board
    ../: menu_config.h
  group app
    ../../src/application/: main.c lvgl_init.c
  group port_lvglv9
    ../../src/lvglv9_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lvgl_demo.c
  group lib
    ../../../../bin/rtl87x2g/rom_lib/: lowerstack.lib ROM_CMSE_Lib.o ROM_NS.lib
    ../../../../bsp/sdk_lib/lib/rtl87x2g/mdk/: rtl87x2g_sdk.lib
    ../../../../subsys/bluetooth/gap_ext/lib/rtl87x2g/bt_host_0_0/mdk/: gap_utils.lib
  group device
    ../../../../bsp/boot/rtl87x2g/: startup_rtl.c system_rtl.c
  group peripheral
    ../../../../bsp/driver/pinmux/src/rtl87x2g/: rtl_pinmux.c
    ../../../../bsp/driver/rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../bsp/driver/dma/src/rtl_common/: rtl_gdma.c
    ../../../../bsp/driver/gpio/src/rtl_common/: rtl_gpio.c
    ../../../../bsp/driver/i2c/src/rtl_common/: rtl_i2c.c
    ../../../../bsp/driver/spi/src/rtl_common/: rtl_spi.c
    ../../../../bsp/driver/tim/src/rtl_common/: rtl_tim.c
    ../../../../bsp/driver/driver_lib/lib/rtl87x2g/mdk/: rtl87x2g_io.lib
    ../../../../bsp/power/: io_dlps.c
    ../../../../subsys/display/hardware/lcdc/src/device/rtl_common/: rtl_lcdc_edpi.c rtl_lcdc.c
  group lcd_low_driver
    ../../../../subsys/display/device/general/lcd/8762G/: st7701s_480480_rgb.c
  group touch_driver
    ../../../../subsys/display/device/general/touch/8762G/: touch_gt911.c
  group LVGL
    ../../../../subsys/lvgl/src/: lv_init.c
    ../../../../subsys/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../../subsys/lvgl/src/display/: lv_display.c
    ../../../../subsys/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../../subsys/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../subsys/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../../subsys/lvgl/src/layouts/: lv_layout.c
    ../../../../subsys/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../../subsys/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../../subsys/lvgl/src/stdlib/: lv_mem.c
    ../../../../subsys/lvgl/src/themes/: lv_theme.c
    ../../../../subsys/lvgl/src/tick/: lv_tick.c
    ../../../../subsys/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../../subsys/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../../../../subsys/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../../../../subsys/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../../../../subsys/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../../../../subsys/lvgl/src/draw/rtk/: font_rendering_utils.c lv_draw_rtk.c lv_draw_rtk_img.c lv_draw_rtk_letter.c
    ../../../../subsys/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../../../../subsys/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../../../subsys/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../../../../subsys/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../../subsys/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../../subsys/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../../../../subsys/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../../../../subsys/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../../../../subsys/lvgl/src/draw/ppe/rtl8773e/: lv_draw_ppe_rtl8773e.c lv_draw_ppe_rtl8773e_fill.c lv_draw_ppe_rtl8773e_img.c lv_ppe_rtl8773e_utils.c
    ../../../../subsys/lvgl/src/draw/ppe/rtl8773g/: lv_draw_mve_iir_blur.c lv_draw_ppe_rtl8773g.c lv_draw_ppe_rtl8773g_blend.c lv_draw_ppe_rtl8773g_box_shadow.c lv_draw_ppe_rtl8773g_fill.c lv_draw_ppe_rtl8773g_img.c lv_draw_ppe_rtl8773g_letter.c lv_draw_ppe_rtl8773g_mask_rect.c lv_draw_ppe_rtl8773g_support.c lv_ppe_rtl8773g_utils.c
    ../../../../subsys/lvgl/src/draw/ppe/rtl87x2g/: lv_draw_ppe_rtl87x2g.c lv_draw_ppe_rtl87x2g_fill.c lv_draw_ppe_rtl87x2g_img.c lv_ppe_rtl87x2g_utils.c
    ../../../../subsys/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../../../../subsys/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../../subsys/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../../subsys/lvgl/src/drivers/evdev/: lv_evdev.c
    ../../../../subsys/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../../../../subsys/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../../../../subsys/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../../../../subsys/lvgl/src/drivers/qnx/: lv_qnx.c
    ../../../../subsys/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../../../../subsys/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../../../../subsys/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../../../../subsys/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../../../../subsys/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../../../../subsys/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../../../../subsys/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../../../../subsys/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../../../../subsys/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../../../../subsys/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../../../../subsys/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../../../../subsys/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../../../../subsys/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../../../../subsys/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../../../../subsys/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../../../../subsys/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../../../../subsys/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../../../../subsys/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../../../../subsys/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../../../../subsys/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../../../../subsys/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
    ../../../../subsys/lvgl/src/layouts/flex/: lv_flex.c
    ../../../../subsys/lvgl/src/layouts/grid/: lv_grid.c
    ../../../../subsys/lvgl/src/libs/avi/: avidec.c lv_avi.c
    ../../../../subsys/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../../../../subsys/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../../subsys/lvgl/src/libs/bmp/: lv_bmp.c
    ../../../../subsys/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../../../../subsys/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../subsys/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../../../subsys/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../../subsys/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../../../../subsys/lvgl/src/libs/gif/: lv_gif.c
    ../../../../subsys/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../../../../subsys/lvgl/src/libs/jpu/: lv_jpu.c
    ../../../../subsys/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../../../subsys/lvgl/src/libs/libpng/: lv_libpng.c
    ../../../../subsys/lvgl/src/libs/Lite3D/: Lite3D_port_lvgl.c
    ../../../../subsys/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../../../subsys/lvgl/src/libs/lz4/: lz4.c
    ../../../../subsys/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../subsys/lvgl/src/libs/rle/: lv_idu.c lv_rle.c
    ../../../../subsys/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../../../subsys/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../../../subsys/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../../../subsys/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../../../subsys/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../../../subsys/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../../../subsys/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../../../../subsys/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../../../../subsys/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../../../../subsys/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../../../../subsys/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../../../../subsys/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../../subsys/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../../subsys/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../../subsys/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../../subsys/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../../subsys/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../../subsys/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../../../subsys/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../../../subsys/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../../../subsys/lvgl/src/others/monkey/: lv_monkey.c
    ../../../../subsys/lvgl/src/others/observer/: lv_observer.c
    ../../../../subsys/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../../subsys/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../../subsys/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../../../subsys/lvgl/src/others/translation/: lv_translation.c
    ../../../../subsys/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../../../subsys/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../../../../subsys/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../../../../subsys/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../../subsys/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../../../subsys/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../../../subsys/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../../../subsys/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../../../../subsys/lvgl/src/themes/default/: lv_theme_default.c
    ../../../../subsys/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../../subsys/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../../subsys/lvgl/src/widgets/3d/: lv_lite3d.c
    ../../../../subsys/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../../subsys/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../../subsys/lvgl/src/widgets/arc/: lv_arc.c
    ../../../../subsys/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../../subsys/lvgl/src/widgets/bar/: lv_bar.c
    ../../../../subsys/lvgl/src/widgets/button/: lv_button.c
    ../../../../subsys/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../../subsys/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../subsys/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../../subsys/lvgl/src/widgets/cardview/: lv_cardview.c
    ../../../../subsys/lvgl/src/widgets/cellular/: lv_cellular.c
    ../../../../subsys/lvgl/src/widgets/chart/: lv_chart.c
    ../../../../subsys/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../../subsys/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../../subsys/lvgl/src/widgets/image/: lv_image.c
    ../../../../subsys/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../../subsys/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../../subsys/lvgl/src/widgets/label/: lv_label.c
    ../../../../subsys/lvgl/src/widgets/led/: lv_led.c
    ../../../../subsys/lvgl/src/widgets/line/: lv_line.c
    ../../../../subsys/lvgl/src/widgets/list/: lv_list.c
    ../../../../subsys/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../../subsys/lvgl/src/widgets/menu/: lv_menu.c
    ../../../../subsys/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../../subsys/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../../subsys/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../../../subsys/lvgl/src/widgets/roller/: lv_roller.c
    ../../../../subsys/lvgl/src/widgets/scale/: lv_scale.c
    ../../../../subsys/lvgl/src/widgets/slider/: lv_slider.c
    ../../../../subsys/lvgl/src/widgets/snapshot/: lv_snapshot_widgets.c
    ../../../../subsys/lvgl/src/widgets/span/: lv_span.c
    ../../../../subsys/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../../subsys/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../../subsys/lvgl/src/widgets/switch/: lv_switch.c
    ../../../../subsys/lvgl/src/widgets/table/: lv_table.c
    ../../../../subsys/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../../subsys/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../../subsys/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../../subsys/lvgl/src/widgets/win/: lv_win.c
    ../../../../subsys/lvgl/demos/: lv_demos.c
    ../../../../subsys/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../../subsys/lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../../../../subsys/lvgl/demos/gltf/: lv_demo_gltf.c
    ../../../../subsys/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../../../../subsys/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../../../subsys/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../../../subsys/lvgl/demos/render/: lv_demo_render.c
    ../../../../subsys/lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_argb8888_premultiplied.c img_render_lvgl_logo_i1.c img_render_lvgl_logo_l8.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb565_swapped.c img_render_lvgl_logo_rgb565a8.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
    ../../../../subsys/lvgl/demos/stress/: lv_demo_stress.c
    ../../../../subsys/lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
    ../../../../subsys/lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
    ../../../../subsys/lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../../../../subsys/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group hal_drivers
    ../../../../subsys/wearable/driver/io/: drv_flash.c drv_dlps.c drv_i2c.c drv_lcd.c drv_gpio.c drv_touch.c
  group Compiler
    ../../../../subsys/wearable/misc/libc/compilers/armlibc/: syscalls.c
    ../../../../subsys/wearable/misc/libc/compilers/mem/: syscall_mem.c
