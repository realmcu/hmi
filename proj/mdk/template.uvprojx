# Keil uVision project template.uvprojx, settings and files
target lvgl (6170000::V6.17::.\ArmCompilerforEmbedded6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  BeforeMake: bash ..\..\..\..\tools\version_generation\version_gen_config.sh ..\version.h
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, DLPS_EN = 0 TEMP_BUILD_OS_IN_NS_ROM
  c misc: -Wno-implicit-function-declaration -gdwarf-3
  c include: ..\..\..\inc\os\freertos;..\..\..\inc\os\osif;..\..\..\src\os\freertos\portable\GCC\ARM_CM33\non_secure;..\..\..\inc\mcu\rtl8762x;..\..\..\inc\platform;..\..\..\inc\platform\cmsis\Core\Include;..\..\..\inc\bluetooth\gap;..\..\..\inc\peripheral;..\..\..\src\app\template;..\;..\..\..\..\os\osif\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
